SRC_URI="http://mirrors.cdn.adacore.com/art/e7942526534a4f9fd031a2fdb510f3779a4a67e0;downloadfilename=gprbuild-gpl-2012-src.tgz"

