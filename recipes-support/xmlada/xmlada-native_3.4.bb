SRC_URI="http://mirrors.cdn.adacore.com/art/0332ffe06bc598f0b94b3a027f30ea2be6dc5dec;downloadfilename=xmlada-4.3w-src.tgz"

SRC_URI[md5sum] = "764c474e8334b263dc3c2dd95693484d"

LICENSE = "GPLv2"

#PR="r1"

inherit native

