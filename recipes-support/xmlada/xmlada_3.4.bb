SRC_URI="http://mirrors.cdn.adacore.com/art/0332ffe06bc598f0b94b3a027f30ea2be6dc5dec;downloadfilename=xmlada-gpl-3.4-src.tgz"

LICENSE = "GPLv2"